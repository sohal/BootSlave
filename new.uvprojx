# Keil uVision project new.uvprojx, settings and files
target Main (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Release_Watchdog +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030x6, SELECT_WATCHDOG
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Sources
    ./: BSP.c CAN.c CRC.c Flash.c main.c Protocol.c Spi.c Usart1.c
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.0
